# Keil uVision project uart.uvproj, settings and files
target 4x_app_crazyflie_rel_a (ARM-ADS)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: crazyfly +hex
  AfterMake: fromelf.exe --bin -o bin\crazyfly.bin bin\crazyfly.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c misc: --c99
  c include: .\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\lib\CMSIS\Core\CM3;.\lib\STM32F10x_StdPeriph_Driver\inc;.\modules\interface;.\config;.\hal\interface;..\uart;.\utils\interface;.\drivers\interface;.\lib\CMSIS\Core\CM3\startup\arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group init
    ./init/: main.c
  group lib
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_tim.c
  group drivers
    ./drivers/src/: motors.c led.c i2cdev.c i2croutines.c mpu6050.c nvic.c
  group modules
    ./modules/src/: crtp.c console.c param.c sensfusion6.c controller.c pid.c system.c comm.c stabilizer.c pidctrl.c commander.c
  group utils
    ./utils/src/: debug.c eprintf.c filter.c fp16.c crc.c
  group hal
    ./hal/src/: uart.c freeRTOSdebug.c imu.c
  group config
    ./config/: config.h FreeRTOSConfig.h nvicconf.h stm32f10x_conf.h
  group startup
    ./lib/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_md.s
  group freeRTOS
    ./FreeRTOS/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group CMSIS
    ./lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Readme
    ./readme/: readme.c
